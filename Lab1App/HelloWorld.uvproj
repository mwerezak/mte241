# Keil uVision project HelloWorld.uvproj, settings and files
target HelloWorld SIM (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: HelloWorld
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup Code
    ./src/: startup_LPC17xx.s
  group System Code
    ./src/: system_LPC17xx.c uart_polling.c
    ../Startup/: Retarget.c RTX_Conf_CM.c
  group Source Code
    ./src/: main.c
  group Documents
    ./: abstract.txt
  group RTX Lib
    ../RTX_CM3/CM3_LE/: RTX_CM3.lib
target HelloWorld RAM (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: as above
  output: HelloWorld
  c flags: Optim=1
  c define: RAM
  memory RVCT4: ROM 0x10000000 size 0x4000
  memory RVCT9: RAM 0x10004000 size 0x4000
  memory RVCT10: RAM 0x2007c000 size 0x8000
